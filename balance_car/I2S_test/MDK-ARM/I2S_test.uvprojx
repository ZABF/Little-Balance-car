# Keil uVision project I2S_test.uvprojx, settings and files
target I2S_test (5060300::V5.06 update 3 (build 300)::ARMCC)
  device: STM32F407VETx STMicroelectronics
  pack: Keil.STM32F4xx_DFP.2.15.0
  cpu: IRAM(0x20000000-0x2001BFFF) IRAM2(0x2001C000-0x2001FFFF) IROM(0x8000000-0x807FFFF) CLOCK(25000000) FPU2 CPUTYPE("Cortex-M4") TZ
  output: I2S_test +hex
  c flags: Optim=2 OneElfS=1 uC99=1 v6Lang=5 v6LangP=3 wLevel=3
  c define: USE_HAL_DRIVER,STM32F407xx,MPL_LOG_NDEBUG=1,EMPL,MPU6050,EMPL_TARGET_STM32F4
  c include: ../Core/Inc;    C:/Users/fcr/STM32Cube/Repository/STM32Cube_FW_F4_V1.26.2/Drivers/STM32F4xx_HAL_Driver/Inc;    C:/Users/fcr/STM32Cube/Repository/STM32Cube_FW_F4_V1.26.2/Drivers/STM32F4xx_HAL_Driver/Inc/Legacy;    C:/Users/fcr/STM32Cube/Repository/STM32Cube_FW_F4_V1.26.2/Drivers/CMSIS/Device/ST/STM32F4xx/Include;    C:/Users/fcr/STM32Cube/Repository/STM32Cube_FW_F4_V1.26.2/Drivers/CMSIS/Include;    ..\Core\MPL\driver;    ..\Core\MPL\eMPL-hal;    ..\Core\MPL\mllite;    ..\Core\MPL\mpl;    ..\Core\MPL\driver\eMPL;    ..\Core\MPL\driver\include;    ..\Core\MPL\driver\stm32L
  library: MicroLIB
  memory RVCT4: ROM 0x8000000 size 0x80000
  memory RVCT9: RAM 0x20000000 size 0x1c000
  memory RVCT10: RAM 0x2001c000 size 0x4000
  group Application/MDK-ARM
    ./: startup_stm32f407xx.s
  group Application/User/Core
    ../Core/Src/: mpu6050_i2c.c mpu6050.c encoder.c control.c main.c gpio.c dcmi.c dma.c i2c.c i2s.c tim.c usart.c stm32f4xx_it.c stm32f4xx_hal_msp.c ov7670_set .c dwt_delay.c sccb.c
    ../Core/Inc/: control.h
    ../../../I2S_test/Core/Src/: myDIP.c
  group Drivers/STM32F4xx_HAL_Driver
    C:/Users/fcr/STM32Cube/Repository/STM32Cube_FW_F4_V1.26.2/Drivers/STM32F4xx_HAL_Driver/Src/: stm32f4xx_hal_dcmi.c stm32f4xx_hal_dcmi_ex.c stm32f4xx_hal_rcc.c stm32f4xx_hal_rcc_ex.c stm32f4xx_hal_flash.c stm32f4xx_hal_flash_ex.c stm32f4xx_hal_flash_ramfunc.c stm32f4xx_hal_gpio.c stm32f4xx_hal_dma_ex.c stm32f4xx_hal_dma.c stm32f4xx_hal_pwr.c stm32f4xx_hal_pwr_ex.c stm32f4xx_hal_cortex.c stm32f4xx_hal.c stm32f4xx_hal_exti.c stm32f4xx_hal_i2c.c stm32f4xx_hal_i2c_ex.c stm32f4xx_hal_i2s.c stm32f4xx_hal_i2s_ex.c stm32f4xx_hal_tim.c stm32f4xx_hal_tim_ex.c stm32f4xx_hal_uart.c
  group Drivers/CMSIS
    ../Core/Src/: system_stm32f4xx.c
  group MPL
    ../Core/MPL/driver/eMPL/: inv_mpu_dmp_motion_driver.c inv_mpu.c
    ../Core/MPL/driver/stm32L/: log_stm32.c
    ../Core/MPL/eMPL-hal/: eMPL_outputs.c
    ../Core/MPL/mllite/: data_builder.c hal_outputs.c message_layer.c ml_math_func.c mlmath.c mpl.c results_holder.c start_manager.c storage_manager.c
  group LIB
    ../Core/MPL/mpl/: libmpllib.lib
software components: CMSIS:CORE 4.3.0
